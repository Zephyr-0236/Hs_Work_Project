# Keil uVision project NFC02_MID.uvprojx, settings and files
target NFC02_MID (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: NFC02_MID +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ..\hardware;../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../IOLDS/01_HW;../IOLDS/02_PL;..\IOLDS\03_LL;../IOLDS/04_APP;../IOLDS/05_UI;../CLRC663/phSubBal/include;../CLRC663/comps/phalI15693/src/Sw;../CLRC663/comps/phalI15693/src;../CLRC663/comps/phpalSli15693/src/Sw;..\CLRC663\comps\phpalSli15693\src;../CLRC663/comps/phalSli/src/Sw;../CLRC663/comps/phhalHw/src/Rc663;../CLRC663/comps/phbalReg/src/Stub;../CLRC663/comps/phKeyStore/src/Rc663;../CLRC663/intfs;../CLRC663/types;../CLRC663/comps/phpalI14443p3a/src;../CLRC663/comps/phpalI14443p3a/src/Sw;../CLRC663/comps/phpalI14443p4a/src/Sw;../CLRC663/comps/phpalI14443p4/src/Sw;../CLRC663/comps/phTools/src;..\CLRC663\comps\phbalReg\src\Stub
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xffff
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c i2c.c iwdg.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c startup_stm32g070xx.s delay.c nfc.c verify.c factory.c EEPROM.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group CLRC663_LIB
    ../CLRC663/comps/phalI15693/src/: phalI15693.c
    ../CLRC663/phSubBal/src/: RegCtl_SpiHw.c
    ../CLRC663/comps/phhalHw/src/Rc663/: phhalHw_Rc663.c phhalHw_Rc663_Cmd.c phhalHw_Rc663_Int.c phhalHw_Rc663_Wait.c
    ../CLRC663/comps/phhalHw/src/: phhalHw.c
    ../CLRC663/comps/phhalHw/src/Callback/: phhalHw_Callback.c
    ../CLRC663/comps/phKeyStore/src/Rc663/: phKeyStore_Rc663.c
    ../CLRC663/comps/phKeyStore/src/: phKeyStore.c
    ../CLRC663/comps/phpalI14443p3a/src/: phpalI14443p3a.c
    ../CLRC663/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c
    ../CLRC663/comps/phpalI14443p4/src/: phpalI14443p4.c
    ../CLRC663/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ../CLRC663/comps/phpalI14443p4a/src/: phpalI14443p4a.c
    ../CLRC663/comps/phpalI14443p4a/src/Sw/: phpalI14443p4a_Sw.c
    ../CLRC663/comps/phpalSli15693/src/: phpalSli15693.c
    ../CLRC663/comps/phTools/src/: phTools.c
    ../CLRC663/comps/phalI15693/src/Sw/: phalI15693_Sw.c
    ../CLRC663/comps/phpalSli15693/src/Sw/: phpalSli15693_Sw.c
    ../CLRC663/comps/phbalReg/src/: phbalReg.c
    ../CLRC663/comps/phbalReg/src/Stub/: phbalReg_Stub.c
  group Hardware
    ../hardware/: rs485.c led.c OS8110.c
  group IOLDS
    ../IOLDS/02_PL/: IOLDS_PL_GPIO.c IOLDS_PL_I2C.c IOLDS_PL_Timer.c IOLDS_PL_UART.c
    ../IOLDS/03_LL/: IOLDS_LL_COMM.c IOLDS_LL_Event.c IOLDS_LL_ISDU.c IOLDS_LL_PDio.c IOLDS_LL_StateJump.c IOLDS_LL_Storage.c IOLDS_LL_Timer.c
    ../IOLDS/04_APP/: IOLDS_APP_DataStorage.c IOLDS_APP_Event.c IOLDS_APP_ISDU.c IOLDS_APP_PDservice.c
software components: CMSIS:CORE 4.3.0
